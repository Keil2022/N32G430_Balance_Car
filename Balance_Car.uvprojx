# Keil uVision project Balance_Car.uvprojx, settings and files
target N32G430 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: N32G430C8L7 Nationstech
  pack: Nationstech.N32G430_DFP.1.0.0
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Balance_Car +hex
  AfterMake: fromelf --bin --output=.\bin\@L.bin .\Objects\@L.axf
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32G430, USE_STDPERIPH_DRIVER
  c include: ..\firmware\CMSIS\device;..\firmware\CMSIS\core;..\firmware\n32g430_std_periph_driver\inc;.\inc;.\src\eMPL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group STARTUP
    ../firmware/CMSIS/device/startup/: startup_n32g430.s
  group CMSIS
    ../firmware/CMSIS/device/: system_n32g430.c
  group USER
    ./src/: main.c n32g430_it.c oled.c i2c_drv.c myiic.c mpu6050.c esp12f_io0.c led.c key.c adc.c exti.c
    ./src/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group LOG
    ./src/: log.c
  group DELAY
    ./src/: bsp_delay.c
  group FWLB
    ../firmware/n32g430_std_periph_driver/src/: misc.c n32g430_adc.c n32g430_beeper.c n32g430_can.c n32g430_comp.c n32g430_crc.c n32g430_dbg.c n32g430_dma.c n32g430_exti.c n32g430_flash.c n32g430_gpio.c n32g430_i2c.c n32g430_iwdg.c n32g430_lptim.c n32g430_pwr.c n32g430_rcc.c n32g430_rtc.c n32g430_spi.c n32g430_tim.c n32g430_usart.c n32g430_wwdg.c
